# file: Stm32-Nucleo.ioc
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Mcu.Family=STM32F3
Mcu.Name=STM32F303R(D-E)Tx
Mcu.Package=LQFP64
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x800
ProjectManager.StackSize=0x800
ProjectManager.TargetToolchain=CMake
RCC.AHBFreq_Value=72000000
RCC.APB1CLKDivider=RCC_HCLK_DIV2
RCC.APB1Freq_Value=36000000
RCC.APB1TimFreq_Value=72000000
RCC.APB2Freq_Value=72000000
RCC.APB2TimFreq_Value=72000000
RCC.CortexFreq_Value=72000000
RCC.FLatency=FLASH_LATENCY_2
RCC.FLatency-AdvancedSettings=FLASH_LATENCY_2
RCC.HCLKFreq_Value=72000000
RCC.HSE_VALUE=8000000
RCC.HSI_VALUE=8000000
RCC.LSE_VALUE=32768
RCC.PLLMUL=RCC_PLL_MUL9
RCC.PRESCALERUSB=RCC_USBCLKSOURCE_PLL_DIV1_5
RCC.RCC_PERIPHCLK_UART4Var=RCC_PERIPHCLK_UART4
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=48000000
STMicroelectronics.X-CUBE-AI.10.2.1.ActivationBufferSizeList=0
STMicroelectronics.X-CUBE-AI.10.2.1.ActivationBuffers=NULL
STMicroelectronics.X-CUBE-AI.10.2.1.HeapSize=0x800
STMicroelectronics.X-CUBE-AI.10.2.1.LatestDirectoryUsed-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=D\:\\Projetos\\Simulador-IA\\Stm32-Nucleo\\modelos_onnx
STMicroelectronics.X-CUBE-AI.10.2.1.MaximumNumberOfInputLayer=1
STMicroelectronics.X-CUBE-AI.10.2.1.MaximumNumberOfOutputLayer=1
STMicroelectronics.X-CUBE-AI.10.2.1.ModelActualCompression-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=0.0
STMicroelectronics.X-CUBE-AI.10.2.1.ModelCompression-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=None
STMicroelectronics.X-CUBE-AI.10.2.1.ModelFlashOccupation-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=0
STMicroelectronics.X-CUBE-AI.10.2.1.ModelHashList=cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334
STMicroelectronics.X-CUBE-AI.10.2.1.ModelKind-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=ONNX
STMicroelectronics.X-CUBE-AI.10.2.1.ModelMacc-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=0
STMicroelectronics.X-CUBE-AI.10.2.1.ModelName-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=nnw_model
STMicroelectronics.X-CUBE-AI.10.2.1.ModelNameList=nnw_model
STMicroelectronics.X-CUBE-AI.10.2.1.ModelRamOccupation-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=0
STMicroelectronics.X-CUBE-AI.10.2.1.ModelStructureFile-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=modelos_onnx/nnw_model.onnx
STMicroelectronics.X-CUBE-AI.10.2.1.ModelType-cecb1dd7d1d9459979e357a24ac3cdf20def2f046a2b66c712fe260a3687e334=STM32Cube.AI MCU runtime
STMicroelectronics.X-CUBE-AI.10.2.1.ReadyForCodeGeneration=false
STMicroelectronics.X-CUBE-AI.10.2.1.StackSize=0x800
STMicroelectronics.X-CUBE-AI.10.2.1.WorkingBufferStartAddrList=0xFFFFFFFF
STMicroelectronics.X-CUBE-AI.10.2.1.XAaCUBEAaAICcArtificialOoIntelligenceJjCore=true
STMicroelectronics.X-CUBE-AI.10.2.1.copyWeightToRam=false
STMicroelectronics.X-CUBE-AI.10.2.1.customLayerConfigEnabled=false
STMicroelectronics.X-CUBE-AI.10.2.1.noOnnxIoTranspose=false
STMicroelectronics.X-CUBE-AI.10.2.1.useInputAllocation=true
STMicroelectronics.X-CUBE-AI.10.2.1.useOutputAllocation=true
VP_STMicroelectronics.X-CUBE-AI_VS_ArtificialOoIntelligenceJjXAaCUBEAaAI_10.2.1.Mode=ArtificialOoIntelligenceJjXAaCUBEAaAI
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
# include <math.h>
# include <stdio.h>
# include <stdlib.h>
/* USER CODE BEGIN Includes */
#include "main.h"
/* MACHINE LEARNING / CONTROLLER includes */
#include "fuzzy-controller.h"
#include "eFLL_wrapper.h"
#include "reg_model.h"
#include "dec_model.h"
#include "svm_model.h"
#include "lgb_model.h"
#include "rfr_model.h"
#include "knn_model.h"
#include "qda_model_wrapper.h"
#include "nnw_model_wrapper.h"
#include "nba_model_wrapper.h"
/* SERIAL MONITOR includes */
#include "serial_logger.h"
/* CONTROLLER INIT REPORTER AND EVALUATION includes */
#include "controller_reporter.h"
#include "controller_profiler.h"
/* STM32 HAL includes */
# include "stm32f3xx_hal.h"
/* USER CODE END Includes */

/* USER CODE BEGIN PV */
Fuzzy *fuzzy = NULL;
UART_HandleTypeDef huart2;
/* USER CODE END PV */

void SystemClock_Config(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  /* USER CODE BEGIN 2 */

  //* Inicializa UART2 para debug e registra o logger */
  {
    GPIO_InitTypeDef GPIO_InitStruct = {0};
    /* Enable clocks */
    __HAL_RCC_USART2_CLK_ENABLE();
    __HAL_RCC_GPIOA_CLK_ENABLE();
    /* PA2 TX PA3 RX */
    GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
    GPIO_InitStruct.Alternate = GPIO_AF7_USART2;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

    /* Configure huart2 */
    huart2.Instance = USART2;
    huart2.Init.BaudRate = 115200;
    huart2.Init.WordLength = UART_WORDLENGTH_8B;
    huart2.Init.StopBits = UART_STOPBITS_1;
    huart2.Init.Parity = UART_PARITY_NONE;
    huart2.Init.Mode = UART_MODE_TX_RX;
    huart2.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    huart2.Init.OverSampling = UART_OVERSAMPLING_16;
    HAL_UART_Init(&huart2);

    /* Aguarda o terminal serial abrir e estabilizar antes de enviar a mensagem. */
    HAL_Delay(2000);
    {
      uint8_t msg[] = "Placa Inicializada com Sucesso!\r\n";
      HAL_UART_Transmit(&huart2, msg, sizeof(msg) - 1, 1000);
    }

    SerialLogger_Init(&huart2);
    /* Diagnostic message to verify serial output immediately after init */
    SerialLogger_Printf("[BOOT] Serial initialized (115200 8N1)\r\n");
  }
  /* Inicializa o função de avaliação */
  ControllerProfiler_Init();

  /* Inicializa e reporta os controladores (Fuzzy, Logistic e DecisionTree) */
  if (ControllerReporter_InitController(CTRL_TYPE_DECISION_TREE) != 0 || ControllerReporter_InitController(CTRL_TYPE_FUZZY) != 0 || ControllerReporter_InitController(CTRL_TYPE_LOGISTIC) != 0 || ControllerReporter_InitController(CTRL_TYPE_SVM) !=0 || ControllerReporter_InitController(CTRL_TYPE_LGB) !=0 || ControllerReporter_InitController(CTRL_TYPE_RFR) !=0 || ControllerReporter_InitController(CTRL_TYPE_QDA) !=0 || ControllerReporter_InitController(CTRL_TYPE_NNW) !=0 || ControllerReporter_InitController(CTRL_TYPE_NBA) !=0)
  {
    Error_Handler();
  }

  float passo = 100.0/299.0;

  float bateria_pct = 0.0; /* variável que carrega procentagem de bateria */
  float taxa_normalizada = 0.0; /* variável que carrega o valor da taxa de sinal recebido */

  int index = 0;

  ControllerProfiler_MedirEReportar("Fuzzy",          FuzModelo_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("Logistica",      RegModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("SVM",            SvmModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("ArvoreDecisao",  DecModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("LGB",            LgbModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("RFR",            RfrModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("QDA",            QdaModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("NNW",            NnwModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  ControllerProfiler_MedirEReportar("KNN",            KnnModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
  //ControllerProfiler_MedirEReportar("NBA",            NbaModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);

  /* USER CODE END 2 */

  /* Infinite loop */

  while (1)
  {

    if (index < 300) {

      index++;
      srand(HAL_GetTick());
      bateria_pct = 100 - (index * passo); /* valor da bateria começando em 100 e acabando em 0 */
      taxa_normalizada = rand() % 100; /* valor da taxa de sinal aleatória entre 0-100 */

      if (taxa_normalizada == 99) { /* normativa do sinal - taxa = 99 é equivalente a sem sinal */
        taxa_normalizada = 0;
      }

      ControllerProfiler_MedirEReportar("Fuzzy",          FuzModelo_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("Logistica",      RegModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("SVM",            SvmModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("ArvoreDecisao",  DecModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("LGB",            LgbModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("RFR",            RfrModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("QDA",            QdaModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("NNW",            NnwModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      ControllerProfiler_MedirEReportar("KNN",            KnnModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);
      //ControllerProfiler_MedirEReportar("NBA",            NbaModel_DecideLigarGPRS, bateria_pct, taxa_normalizada, index);

    }

  }
}
/* USER CODE BEGIN CLOCK CONFIG*/

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSI;
  RCC_OscInitStruct.PLL.PREDIV = RCC_PREDIV_DIV2;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL16;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK)
  {
    Error_Handler();
  }
}

/* USER CODE END CLOCK CONFIG*/

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
